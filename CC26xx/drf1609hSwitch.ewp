# IAR project drf1609hSwitch.ewp, settings and files
configuration SmartRF06 (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ZSTACK_MANUAL_START; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_ON_OFF; ZCL_IDENTIFY; ZCL_EZMODE; xZCL_GROUPS; xZCL_SCENES; ZCL_STANDALONE; ZG_SECURE_ENABLED; ewarm; USE_ICALL; HEAPMGR_SIZE=4096; ICALL_HOOK_ABORT_FUNC=halAssertHandler; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_5X5; xTI_DRIVERS_LCD_INCLUDED; BOARD_DRF1609H; xBOARD_LIVOLO
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg\compiler.opt.defs; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.cfg
  ICCARM.CCIncludePath2: .; ..\..\Source; ..\..\..\common\CC26xx; ..\..\..\common\CC26xx\appport; ..\..\..\common\CC26xx\SmartRF06; ..\..\..\..\..\Components\applib\heap; ..\..\..\..\..\Components\mac\include\cc26xx; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_common\cc26xx; ..\..\..\..\..\Components\hal\target\CC2650\rom; ..\..\..\..\..\Components\hal\target\CC2650TIRTOS; ..\..\..\..\..\Components\icall\include; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\nv; ..\..\..\..\..\Components\services\nv\cc26xx; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\icall; ..\..\..\..\..\Components\stack\icall\client; ..\..\..\..\..\Components\stack\zcl; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib; source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: drf1609hSwitch.hex
  ILINK.IlinkOutputFile: SampleSwitch.out
  ILINK.IlinkConfigDefines: CC2650=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.xcl
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; ..\..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    source/: board_key.c board_key.h board_lcd.c board_lcd.h board_led.c board_led.h
    ./: switch.c switch.h znwk_config.h zstart_config.h
    ../../../common/CC26xx/: util.c util.h zcl_port.c zcl_port.h zstart.c zstart.h
  group Config
    ./: app.cfg cc26xx_app.icf
    ../../../Core/Thread/CC26xx/Config/: coreEndDevice.cfg coreEndDevice.xcl
  group ICall
    ../../../../../Components/icall/ports/tirtos/: CryptoBoard.c ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../Components/icall/include/: CryptoBoard.h ICall.h ICallCC26xxDefs.h
    ../../../../../Components/applib/heap/: heapmgr.h
    ./: ICallAddrs.h
  group Services
    ../../../../../Components/services/nv/: nvintf.h
    ../../../../../Components/services/nv/cc26xx/: nvoctp.c nvoctp.h
    ../../../../../Components/hal/target/_common/cc26xx/: pwrmon.c pwrmon.h
  group Startup
    source/: Board.c Board.h
    ../../../common/CC26xx/SmartRF06/: ccfg.c
    ./: main.c
  group ZCL
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h
  group ZStack
    ../../../../../Components/stack/icall/: zstack.h zstackmsg.h
    ../../../../../Components/stack/icall/client/: zstackapi.c zstackapi.h
